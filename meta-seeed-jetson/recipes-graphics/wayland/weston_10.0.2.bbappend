EXTRA_OEMESON:append = " -Dtools=calibrator,debug,info,terminal,touch-calibrator"
