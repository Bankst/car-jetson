inherit kf6_kcoreaddons
