inherit kf6_kauth
