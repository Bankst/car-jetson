inherit kf6_kdoctools
