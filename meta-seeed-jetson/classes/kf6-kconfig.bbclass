inherit kf6_kconfig
